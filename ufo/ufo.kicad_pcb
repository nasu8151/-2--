# Repository nasu8151/-2--

File README.md:

# ファイルの配置
- kouni_UFOcatcher_main  : 中央制御用プログラム
- kouni_UFOcatcher_moter : 巻き上げ機用プログラム
- ufo                    : アーム部分の基板データ
- winder                 : 巻き上げ機部分の基板データ

## KiCad design ufo/ufo.kicad_pcb

Parts:
C1: 22u; C_0805_2012Metric
C2: 10u; C_0805_2012Metric
C3: 100u; CP_Radial_D6.3mm_P2.50mm
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1: Servo1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: Servo2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Battery; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
MD1: OKL-T_6-W12N-C; MURATA_OKL-T-6-W12N-C_0; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C; MOUSER_DESCRIPTION Non-Isolated DC/DC Converters 12Vin .59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
R1: 430; R_0603_1608Metric
R2: 910; R_0603_1608Metric
R3: 10k; R_0603_1608Metric
R4: 1k; R_0603_1608Metric
U1: MOUDLE-SEEEDUINO-XIAO-ESP32C3; MOUDLE14P-SMD-2.54-21X17.8MM

Connections:
+3V3: U1.12 (3V3)
GND: C1.2, C2.2, C3.2, D1.3 (VSS), J1.3, J2.3, J3.2, MD1.1 (~ON/OFF_CONTROL), MD1.3 (1_GROUND), MD1.7 (2_GROUND), R2.1, R4.2, U1.13 (GND)
unnamed: C1.1, J3.1, MD1.2 (VIN), R3.2
unnamed: MD1.6 (TRIM), R1.1
unnamed: R1.2, R2.2
Servo1: J1.1, U1.1 (PA02_A0_D0)
Servo2: J2.1, U1.2 (PA4_A1_D1)
VCC: C2.1, C3.1, D1.1 (VDD), J1.2, J2.2, MD1.4 (VOUT), MD1.5 (SENSE), U1.14 (5V)
V_MONITOR: R3.1, R4.1, U1.3 (PA10_A2_D2)
WS2812: D1.4 (DIN), U1.5 (PA8_A4_D4_SDA)

Board: 2 copper layers, 58.0 x 58.0 mm, 13 parts (0 on the bottom side), 9 nets.

File ufo/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0805,1,22u,
C2,0805,1,10u,
C3,CP_Radial_D6.3mm_P2.50mm,1,100u,
D1,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,1,WS2812B,
J1,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,Servo1,
J2,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,Servo2,
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Battery,
MD1,MURATA_OKL-T-6-W12N-C_0,1,OKL-T_6-W12N-C,OKL-T/6-W12N-C
R1,0603,1,430,
R2,0603,1,910,
R3,0603,1,10k,
R4,0603,1,1k,
U1,MOUDLE14P-SMD-2.54-21X17.8MM,1,MOUDLE-SEEEDUINO-XIAO-ESP32C3,

## KiCad design 芝生祭高2企画コントローラー基板/芝生祭高2企画コントローラー基板.kicad_pcb

Parts:
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1, J2: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J3: micomL; PinHeader_1x19_P2.54mm_Vertical
J4: micomR; PinHeader_1x19_P2.54mm_Vertical
J5, J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1, R2: R; R_0805_2012Metric

Connections:
3.3V: D1.1 (VDD), J1.2, J3.1, R1.1, R2.1
25: D1.4 (DIN), J3.9
32: J3.7, J5.1, R1.2
33: J3.8, J6.1, R2.2
34: J1.4, J3.5
35: J1.3, J3.6
GND: D1.3 (VSS), J1.1, J1.6, J3.14, J4.1, J4.7, J5.2, J6.2

Board: 2 copper layers, 70.0 x 70.0 mm, 9 parts (0 on the bottom side), 7 nets.

File 芝生祭高2企画コントローラー基板/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
D1,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,1,WS2812B,
"J1, J2",PinHeader_1x06_P2.54mm_Vertical,2,Conn_01x06_Pin,
J3,PinHeader_1x19_P2.54mm_Vertical,1,micomL,
J4,PinHeader_1x19_P2.54mm_Vertical,1,micomR,
"J5, J6",PinHeader_1x02_P2.54mm_Vertical,2,Conn_01x02_Pin,
"R1, R2",0805,2,R,

## KiCad design winder/winder.kicad_pcb

Parts:
C1: 0.33u; C_0603_1608Metric
C2: 2.2u; C_0603_1608Metric
C3: 470u; CP_Radial_D10.0mm_P5.00mm
C4, C5: 0.1u; C_0603_1608Metric
D1: Status; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2: M3; MountingHole_3.2mm_M3
J1: Power; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Encoder; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: USB; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Motor; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5, J7: RS485; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: UART; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23
R1, R2, R3, R7, R8, R9, R10: 10k; R_0603_1608Metric
R4: 0.1Ω; R_2512_6332Metric
R5: 7.5k; R_0603_1608Metric
R6: 2.2k; R_0603_1608Metric
SW1, SW2: SW_Push; SKRPABE010
U1: ESP32-C3-WROOM-02
U2: NJM2845DL1; TO-252-2
U3: TB67H450FNG; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U4: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C2.1, D1.1 (VDD), J8.1, Q1.1 (G), Q2.1 (G), R1.1, R2.1, R3.1, R6.1, R8.1, R9.1, U1.1 (3V3), U2.3 (OUT), U4.8 (VCC)
/Motor1: J4.2, U3.6 (OUT1)
/Motor2: J4.1, U3.8 (OUT2)
D+: J3.1, U1.14 (IO19)
D-: J3.2, U1.13 (IO18)
DE: U1.10 (IO10), U4.2 (~RE), U4.3 (DE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.3 (VSS), J1.2, J2.2, J8.2, R4.2, R5.2, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A), U1.9 (GND), U1.19 (GND), U2.2 (GND), U3.1 (GND), U3.9 (EP), U4.5 (GND)
IO0: J8.3, U1.18 (IO0)
IO1: J8.4, U1.17 (IO1)
MD_A: U1.3 (IO4), U3.3 (IN1)
MD_B: U1.4 (IO5), U3.2 (IN2)
unnamed: D1.4 (DIN), U1.15 (IO3)
unnamed: J2.3, Q1.3 (D), R7.2
unnamed: J2.4, Q2.3 (D), R10.2
unnamed: J5.1, J7.1, U4.6 (A)
unnamed: J5.2, J7.2, U4.7 (B)
unnamed: R3.2, SW1.1, SW1.2, U1.2 (EN)
unnamed: R1.2, U1.7 (IO8)
unnamed: R2.2, SW2.1, SW2.2, U1.8 (IO9)
unnamed: R4.1, U3.7 (RS)
unnamed: C5.1, R5.1, R6.2, U3.4 (VREF)
Phase_A: Q1.2 (S), R8.2, U1.5 (IO6)
Phase_B: Q2.2 (S), R9.2, U1.6 (IO7)
RX: J6.2, U1.11 (IO20/RXD), U4.1 (RO)
TX: J6.1, U1.12 (IO21/TXD), U4.4 (DI)
VDD: C1.1, C3.1, C4.1, J1.1, J2.1, R7.1, R10.1, U2.1 (IN), U3.5 (VM)

Notes on the sheet:
WiFiで無理だった時用 いったん未実装にする

Board: 2 copper layers, 47.0 x 38.7 mm, 34 parts (6 on the bottom side), 26 nets.

File winder/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,0.33u,
C2,0603,1,2.2u,
C3,CP_Radial_D10.0mm_P5.00mm,1,470u,
"C4, C5",0603,2,0.1u,
D1,LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm,1,Status,
J1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Power,
J2,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,Encoder,
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,USB,
J4,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Motor,
"J5, J7",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,RS485,
J6,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,UART,
J8,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
"Q1, Q2",SOT-23,2,BSS138,
"R1, R10, R2, R3, R7, R8, R9",0603,7,10k,
R4,2512,1,0.1Ω,
R5,0603,1,7.5k,
R6,0603,1,2.2k,
"SW1, SW2",SKRPABE010,2,SW_Push,
U1,ESP32-C3-WROOM-02,1,ESP32-C3-WROOM-02,
U2,TO-252-2,1,NJM2845DL1,
U3,HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm,1,TB67H450FNG,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,MAX3485,

## Commit log

2025-09-25 初期値を指定
2025-09-25 モータープログラムいったん完成
2025-09-25 ターゲット座標の初期化関数を追加し、データ送信時に呼び出すように変更。不要なコードをコメントアウト。
2025-09-26 モータープログラム修正：PID制御の頻度を上げた
2025-09-26 masterのscan関数とmanage関数をコピーしました。
2025-09-26 masterのScan関数とManage関数を今度は本当にコピーしました。
2025-09-26 新しい関数kouni_UFOcatcher_main_v2.0を追加しました
2025-09-26 動作を確認しました。遅延があるため、調整が必要です。
2025-09-26 動作を確認しました。こっちが本命です。
2025-09-26 複数のESP32デバイス間でのESPNow通信を実装し、ジョイスティック入力を追加しました。また、データ送信のための構造体を更新し、ボタン操作によるアームの状態管理を追加しました。
